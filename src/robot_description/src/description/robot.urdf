Commit message: 12:12

File: src/robot_description/src/description/robot.urdf (robot description, URDF)
Before this commit: robot simple_differential_robot, 6 links, 5 joints
Links:
- link base_link: mass 10.0 -> 4.0
